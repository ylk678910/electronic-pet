# Keil uVision project Electronic_Pet_Machine.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Electronic_Pet_Machine
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\inc\Driver;.\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\CMSIS\CM0\CoreSupport;.\Header_File
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group Startup
    ./CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
    ./CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Main
    ./: main.c Varible.c Animation.c LCD_Function.c
  group NUC140_Driver
    ./src/Driver/: DrvSYS.c DrvGPIO.c DrvTIMER.c
    ./src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.c ScanKey.c
  group Header
    ./Header_File/: GPIO.h Function_Define.h LCD_Define.h Pet_CH_Define.h
